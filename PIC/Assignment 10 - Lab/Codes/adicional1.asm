ORG 100H
H EQU 2
V EQU 2

MOV AL, 13H
MOV AH, 0
INT 10H     ; SET GRAPHICS VIDEO MODE.

MOV AL, 1100B
MOV CX,100
MOV DX,100
MOV AH, 0CH
INT 10H     ; SET PIXEL. 


LADO1: 
MOV AL, 1100B
ADD CX,H
SUB DX,V
MOV AH, 0CH
INT 10H     ; SET PIXEL.
CMP CX,110
JNE LADO1


LADO2: 
MOV AL, 1100B
ADD CX,H
ADD DX,V
MOV AH, 0CH
INT 10H     ; SET PIXEL.
CMP CX,120
JNE LADO2 


LADO3: 
MOV AL, 1100B
SUB CX,H
MOV AH, 0CH
INT 10H     ; SET PIXEL.
CMP CX,100
JNE LADO3
RET 

 