#INCLUDE "P16F628a.INC"

#define MINHA_MATRICULA_MAIS_100   .135

ORG 0x00						  
    GOTO INICIALIZA              

ORG 0x04
    BCF     INTCON, T0IF 
    BTFSC   PORTB,0
    GOTO    RB0_HIGH
    
RB0_LOW:
    BSF     PORTB,0
    MOVLW   .0
    MOVWF   TMR0 
    RETFIE
    
RB0_HIGH:
    BCF     PORTB,0
    MOVLW   MINHA_MATRICULA_MAIS_100
    MOVWF   TMR0 
    RETFIE

INICIALIZA:
    BANKSEL TRISB
    MOVLW   0x00
    MOVWF   TRISB
    BANKSEL OPTION_REG 
    MOVLW   0x83
    MOVWF   OPTION_REG 
    BANKSEL INTCON 
    MOVLW   0xA0
    MOVWF   INTCON 

MAIN:
    GOTO    MAIN

END
